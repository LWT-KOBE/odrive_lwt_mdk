# Keil uVision project motorF4.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: motorF4 +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\STARTUP;.\FWLIB\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\USB_App\inc;.\USB_Device\inc;.\USB_Driver\inc;.\Hardware;.\MotorControl;.\USER;.\SEGGER;.\SEGGER\RTT;.\SEGGER\Config;.\SEGGER\Syscalls;.\Scheduler;.\Communication;.\IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./STARTUP/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group lib
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group system
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./IAP/: IAP.c
    ./Hardware/: dwt.c
  group USB App
    ./USB_App/src/: stm32fxxx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB Device
    ./USB_Device/src/: usbd_cdc_core.c usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver
    ./USB_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group SEGGER_RTT
    ./SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Communication
    ./Communication/: communication_usb.c communication_can.c communication_usart.c
  group hardware
    ./Hardware/: adc.c timer.c usart2.c spi3.c vofa.c can.c
  group MotorControl
    ./MotorControl/: utils.c arm_cos_f32.c foc.c open_loop_controller.c board.c motor.c axis.c encoder.c trapTraj.c controller.c flash_writer.c anticogging.c ntc.c
  group Scheduler
    ./Scheduler/: scheduler.c debug.c
  group user
    ./USER/: main.c
